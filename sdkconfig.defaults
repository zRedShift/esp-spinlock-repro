## sdkconfig.defaults
```kconfig
CONFIG_ESP_TIMER_SUPPORTS_ISR_DISPATCH_METHOD=y
CONFIG_ESP_EVENT_POST_FROM_ISR=y
CONFIG_ESP_SYSTEM_EVENT_TASK_STACK_SIZE=4096
```
